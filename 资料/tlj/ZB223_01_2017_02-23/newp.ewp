# IAR project newp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 Freescale S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; EVB_S32K144
  ICCARM.CCIncludePath2: common; core\arm_cortex_M4; core\headers; core\startup; src; S32K144_Module; function; patch
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ZB209_223.s19
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: config_files\240KB_APP_Pflash_.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ZB223YY01 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; EVB_S32K144; ZB223YY01
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: ZB209_223YY01.s19
configuration ZB223BYY00 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; EVB_S32K144; ZB223BYY00
  OBJCOPY.OOCOutputFile: ZB209_223BYY00.s19
configuration ZB206B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; EVB_S32K144; ZB206B
  OBJCOPY.OOCOutputFile: ZB206B.s19
configuration ZB223BYY0A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; EVB_S32K144; ZB223BYY00; ZB223BYY0A
  OBJCOPY.OOCOutputFile: ZB209_223BYY0A.s19
  group arm_cortex_M4
    core/arm_cortex_M4/: arm_cm4.c arm_cm4.h
  group common
    common/: common.c io.c printf.c uart.c
  group config
    function/: configFile.h
    patch/: HwMacroPatch.h
  group patch
    patch/: BacklightControl.c deepSleep.c motorPatch.c
  group s32k144_Module
    S32K144_Module/: ap_lpit.c ap_S32K1xx_adc.c ap_S32K1xx_FlexCAN.c ap_S32K1xx_FTM.c ap_S32K1xx_lptmr.c systick.c
  group src
    function/: BitMacros.c CanMsgOut.c configFile.c display.c DS1302.c EngineDiagnose_DM1.c infoManage.c IS31FL3733_I2C.c ISR.C J1939.c KeyDeal.c KeyProcess.c LcmDisp.c Led.c load_deal.c LoadOutputCondition.c M41T00.c message.c physicalq.c sensor.c sound.c StepDeal.c TJA1145.c TW_FontOsd.C TW_SpiOsd.c WaitTimer.c xgate.c
    src/: main.c sysinit.c vectors.c wdog.c
  group startup
    config_files/: 240KB_APP_Pflash_.icf 256KB_Pflash_64KB_Dflash.icf 64KB_Ram.icf
    core/startup/: crt0.s start.c start.h startup.c startup.h
